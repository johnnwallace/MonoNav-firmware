## configs/cf2_wifi_defconfig
```kconfig
CONFIG_PLATFORM_CF2=y
CONFIG_DECK_CPX_HOST_ON_UART2=y
CONFIG_DECK_FORCE="cpxOverUART2"
```
